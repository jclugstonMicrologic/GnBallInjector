# IAR project BIC.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7A3 Atmel AT91SAM7A3
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\; C:\Software\GN_BallInjector_AT91\BIC\include; C:\Software\GN_BallInjector_AT91\BIC\SrcIar
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: as above
  XLINK.XclFile: C:\Software\GN_BallInjector_AT91\BIC\BIC_FW\at91SAM7A3_NoRemap.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: adcFd.c adcHi.c CpuPorts.c flash.c KeypadFd.C lcdFd.c lcdHi.c main.c motorcntrl.c PwmDriverFd.c PwmFd.c pwmHi.c readme.txt switchFd.c TaskManager.c Timer.c
    ../SrcIAR/: Cstartup.s79 Cstartup_SAM7.c
    ../../../Vortex/Plant Controller/Plant Controller FW/: SPIHI.C
