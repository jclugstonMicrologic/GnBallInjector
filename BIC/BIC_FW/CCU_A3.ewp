# IAR project CCU_A3.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7A3 Atmel AT91SAM7A3
  ICCARM.CCDefines: ESS; LOAD_TEST_
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\; C:\Software\CompactCompressors\CCU\include; C:\Software\CompactCompressors\CCU\SrcIar
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: $TOOLKIT_DIR$\INC\; C:\Software\CompactCompressors\CCU\include; C:\Software\CompactCompressors\CCU\SrcIAR
  XLINK.XclFile: C:\Software\CompactCompressors\CCU\CCU_FW_A3\at91SAM7A3_NoRemap.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LOAD_TEST_
  group (top)
    ./: adcFd.c adcHi.c AlarmFd.C cdc_enumerate.c CompressorMachineFd.c CpuPorts.c DacFd.c dacHi.c dbgu.c digitalInFd.c EngineCntrlFd.c extAdcFd.c extAdcHi.c GsmRadioFd.c HeaterFd.c interrupt_Usart.c KeypadFd.C lcdFd.c lcdHi.c main.c memoryFd.c memoryHi.c PidFd.c PwmDriverFd.c PwmFd.c pwmHi.c readme.txt rtcFd.c rtcHi.c SerialFd.c SPIHI.C srHi.c switchFd.c TaskManager.c Timer.c UsbComFd.c
    ../SrcIAR/: Cstartup.s79 Cstartup_SAM7.c
